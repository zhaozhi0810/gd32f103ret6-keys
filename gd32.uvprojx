# Keil uVision project gd32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./src/: main.c systick.c gd32f10x_it.c btns.c uart.c
software components: CMSIS:CORE 5.3.0, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
